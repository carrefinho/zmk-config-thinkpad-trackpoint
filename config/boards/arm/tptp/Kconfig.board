## config/boards/arm/tptp/Kconfig.board
```kconfig
# Copyright (c) 2021 Nick Winans
# SPDX-License-Identifier: MIT

config BOARD_TPTP
	bool "ThinkPad TrackPoint"
	depends on SOC_NRF52840_QIAA
```
